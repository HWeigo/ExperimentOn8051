SS EQU 30H
MINUTE2 EQU 5EH
MINUTE1 EQU 5FH
SECOND2 EQU 60H
SECOND1 EQU 61H
ORG 0000H
LJMP MAIN

ORG 001BH
AJMP TIME1
ORG 060H
MAIN: MOV SP,#70H
	  MOV SS,#00H
	  MOV SECOND1,#0H
	  MOV SECOND2,#0H
	  MOV MINUTE1,#0H
	  MOV MINUTE2,#0H
	  
	  
	  ACALL SET_TIME01
START :
ACALL DISP
MOV A,SS
SUBB A,#50H
JNZ MINI2

MOV SS,#00H
INC SECOND1
MOV  A,SECOND1
CJNE A,#0AH,SEC2
MOV SECOND1,#0H
INC SECOND2
SEC2: MOV A,SECOND2
	 CJNE A,#06H,MINI1
	 MOV SECOND2,#0H
	 INC MINUTE1
MINI1: MOV A,MINUTE1
	  CJNE A,#0AH,MINI2
	  MOV MINUTE1,#0H
	  INC MINUTE2
MINI2: 
AJMP START	  

SET_TIME01: MOV TMOD,#10H
	       
		   
    	   MOV TH1,#0C8H
           MOV TL1,#00H
           SETB EA
           SETB ET1
		   
           SETB TR1
		   RET

DISP:JNB P1.0,PAUSE
     JNB P1.1,MAIN
	 JNB P1.2,CONTINUE
     MOV A,MINUTE2
     MOV DPTR,#TAB
     MOVC A,@A+DPTR
     MOV DPTR,#7FFBH
     MOVX @DPTR,A
	 MOV A,MINUTE1
     MOV DPTR,#TAB
     MOVC A,@A+DPTR
     MOV DPTR,#7FFAH
     MOVX @DPTR,A
	 MOV A,SECOND2
     MOV DPTR,#TAB
     MOVC A,@A+DPTR
     MOV DPTR,#7FF9H
     MOVX @DPTR,A
	 MOV A,SECOND1
     MOV DPTR,#TAB
     MOVC A,@A+DPTR
     MOV DPTR,#7FF8H
     MOVX @DPTR,A
	 RET
TIME1: PUSH ACC
       MOV TH1,#0B8H
       MOV TL1,#0FFH
	   INC SS
	   POP ACC
       RETI
TAB: DB 0C0H,0F9H,0A4H,0B0H
	 DB 99H,92H,82H,0F8H
	 DB 80H,90H,88H,83H
	 DB 0C6H,0A1H,86H,8EH
	 
PAUSE: CLR TR1
       JMP DISP
      
CONTINUE: SETB TR1
          JMP DISP 
END     
      

	   



	 