# Keil uVision project Experiment.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Experiment_2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Experiment5/: Experiment_5hw.asm Experiment_5hw_display.asm
    ../Experiment3/: experiment_3withComments.asm Experiment_3.asm
